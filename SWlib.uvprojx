# Keil uVision project SWlib.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SWlib
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=5 wLevel=3
  c include: nrf24l01_receiver_lpc17xx/inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group New Group
    ./nrf24l01_receiver_lpc17xx/src/: main.c MyNrfFunctions.c MyGuiFunctions.c MyLcdFunctions.c MyUsartFunctions.c MyJoystickFunctions.c
  group NRF
    ./nrf24l01_receiver_lpc17xx/src/: cpu_lpc1000.h lpc17xx_clkpwr.c cpu_lpc1000.c lpc17xx_libcfg_default.c lpc17xx_ssp.c nrf24l01.c nrf24l01.h
    ./nrf24l01_receiver_lpc17xx/inc/: lpc17xx_ssp.h lpc17xx_libcfg_default.h lpc17xx_clkpwr.h lpc_types.h
  group LCD
    ./nrf24l01_receiver_lpc17xx/src/: Open1768_LCD.c Open1768_LCD.h asciiLib.h asciiLib.c LCD_ILI9325.c LCD_ILI9325.h
software components: CMSIS:CORE 5.6.0, Board Support:Joystick 1.0.0, Device:GPDMA 1.4.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
